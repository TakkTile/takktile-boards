# Repository TakkTile/takktile-boards (continued)

## EAGLE design eagle/roadkill.brd (continued)

Parts:
C13, C14, C15, C16, C17: CAP_CERAMIC0603; 0603
PROG2: HEADER-2X3; 2X03
S02, S12, S22, S32, S42: MPL115A; LGA-8
UC2: ATTINY24QFN; QFN20

Connections:
3.3V: PROG2.2, S02.1 (VDD), S02.4 (SHDN), S12.1 (VDD), S12.4 (SHDN), S22.1 (VDD), S22.4 (SHDN), S32.1 (VDD), S32.4 (SHDN), S42.1 (VDD), S42.4 (SHDN), UC2.9 (VCC); also elsewhere on the board
ADDR02: UC2.14 (PB2)
CAP02: C13.1, S02.2 (CAP)
CAP12: C14.1, S12.2 (CAP)
CAP22: C15.1, S22.2 (CAP)
CAP32: C16.1, S32.2 (CAP)
CAP42: C17.1, S42.2 (CAP)
GND: C13.2, C14.2, C15.2, C16.2, C17.2, PROG2.6, S02.3 (GND), S12.3 (GND), S22.3 (GND), S32.3 (GND), S42.3 (GND), UC2.0 (GND), UC2.8 (GND), UC2.11 (PB0), UC2.12 (PB1), UC2.15 (PA7/ADC7); also elsewhere on the board
RESET2: PROG2.5, UC2.13 (PB3/RESET)
RST02: S02.5 (RST), UC2.5 (PA0/ADC0)
RST12: S12.5 (RST), UC2.4 (PA1/ADC1)
RST22: S22.5 (RST), UC2.3 (PA2/ADC2)
RST32: S32.5 (RST), UC2.2 (PA3/ADC3)
RST42: PROG2.1, S42.5 (RST), UC2.20 (PA5/MISO)
SCL: PROG2.3, S02.8 (SCL), S12.8 (SCL), S22.8 (SCL), S32.8 (SCL), S42.8 (SCL), UC2.1 (PA4/SCL); also elsewhere on the board
SDA: PROG2.4, S02.7 (SDA), S12.7 (SDA), S22.7 (SDA), S32.7 (SDA), S42.7 (SDA), UC2.16 (PA6/MOSI); also elsewhere on the board

Parts:
C18, C19, C20, C21, C22: CAP_CERAMIC0603; 0603
PROG3: HEADER-2X3; 2X03
S03, S13, S23, S33, S43: MPL115A; LGA-8
UC3: ATTINY24QFN; QFN20

Connections:
3.3V: PROG3.2, S03.1 (VDD), S03.4 (SHDN), S13.1 (VDD), S13.4 (SHDN), S23.1 (VDD), S23.4 (SHDN), S33.1 (VDD), S33.4 (SHDN), S43.1 (VDD), S43.4 (SHDN), UC3.9 (VCC); also elsewhere on the board
ADDR03: UC3.15 (PA7/ADC7)
CAP03: C18.1, S03.2 (CAP)
CAP13: C19.1, S13.2 (CAP)
CAP23: C20.1, S23.2 (CAP)
CAP33: C21.1, S33.2 (CAP)
CAP43: C22.1, S43.2 (CAP)
GND: C18.2, C19.2, C20.2, C21.2, C22.2, PROG3.6, S03.3 (GND), S13.3 (GND), S23.3 (GND), S33.3 (GND), S43.3 (GND), UC3.0 (GND), UC3.8 (GND), UC3.11 (PB0), UC3.12 (PB1), UC3.14 (PB2); also elsewhere on the board
RESET3: PROG3.5, UC3.13 (PB3/RESET)
RST03: S03.5 (RST), UC3.5 (PA0/ADC0)
RST13: S13.5 (RST), UC3.4 (PA1/ADC1)
RST23: S23.5 (RST), UC3.3 (PA2/ADC2)
RST33: S33.5 (RST), UC3.2 (PA3/ADC3)
RST43: PROG3.1, S43.5 (RST), UC3.20 (PA5/MISO)
SCL: PROG3.3, S03.8 (SCL), S13.8 (SCL), S23.8 (SCL), S33.8 (SCL), S43.8 (SCL), UC3.1 (PA4/SCL); also elsewhere on the board
SDA: PROG3.4, S03.7 (SDA), S13.7 (SDA), S23.7 (SDA), S33.7 (SDA), S43.7 (SDA), UC3.16 (PA6/MOSI); also elsewhere on the board

Board: 2 copper layers, 50.0 x 80.0 mm, 64 parts (23 on the bottom side), 56 nets.

Other parts of the board:
U$1, U$2, U$3, U$4: STAND-OFF

## EAGLE design eagle/row0.brd

Board: 2 copper layers, 38.0 x 8.0 mm, 14 parts (5 on the bottom side), 15 nets.

Parts:
C0, C2, C3, C4: 0402
C1: 0603
OUT: 1X04_OVAL
PROG: 2X03
S00, S01, S02, S03, S04: MPL115A; LGA-8
U$5: ATTINY45; SO08-EIAJ
UC0: ATTINY24QFN; QFN20

Connections:
3.3V: OUT.2, PROG.2, S00.1, S00.4, S01.1, S01.4, S02.1, S02.4, S03.1, S03.4, S04.1, S04.4, UC0.9
CAP00: C0.1, S00.2
CAP01: C1.1, S01.2
CAP02: C2.1, S02.2
CAP03: C3.1, S03.2
CAP04: C4.1, S04.2
GND: C0.2, C1.2, C2.2, C3.2, C4.2, OUT.4, PROG.6, S00.3, S01.3, S02.3, S03.3, S04.3, UC0.0, UC0.8
RESET: PROG.5, UC0.13
RST0: S00.5, UC0.5
RST1: S01.5, UC0.4
RST2: S02.5, UC0.3
RST3: S03.5, UC0.2
RST4: PROG.1, S04.5, UC0.20
SCL: OUT.3, PROG.3, S00.8, S01.8, S02.8, S03.8, S04.8, UC0.1
SDA: OUT.1, PROG.4, S00.7, S01.7, S02.7, S03.7, S04.7, UC0.16

## Code that names these connections

File pindefs.h:

#define RST0 PA0
#define RST1 PA1
#define RST2 PA2
#define RST3 PA3
#define SCL PA4
#define RST4 PA5
#define SDA PA6
#define PA7 ADDR3
#define PB0 ADDR0
#define PB1 ADDR1
#define PB2 ADDR2

## Commit log

2012-02-09 initial commit; includes USI-based I2C library and row-zero schematics
2012-02-09 bit more routing
2012-02-09 moved parts to nonolith eagle library, renamed headers
2012-02-17 converted to eagle v6 format, small routing modifications
2012-04-17 compiles for the attiny44 with fuses to run at 8MHz off internal RC osc
2012-04-18 added pindefs from schematic
2012-04-18 added configPins, a bunch of #defines, and code to calculate base I2C address
2012-04-18 oops, had some of my pin #defines backwards.
2012-04-18 replaced base address calculation with more efficient code
2012-04-18 majorly reformatted usiTwiSlave.c / usiTwiSlave.h to meet my arbitrary sense of aesthetics and to increase readability
2012-04-18 more cleanup of usiTwiSlave.c
2012-04-18 more cleanup.
2012-04-18 guess what??? more cleanup\!
2012-04-18 overzealous xing fixed
2012-04-18 s/next/then/
2012-04-18 killed unused header file
2012-04-19 added eagle stuff
2012-04-19 bit of modification
2012-04-19 have slaveAddress set from main.c, change slaveAddress from 8b to 7b to match compare at usiTwiSlave.c:364
2012-04-19 move slaveAddress definition to usiTwiSlave.h
2012-04-19 wow, iotnx4.h is *useless*
2012-04-19 s/dos/unix/ line encodings
2012-04-19 s/#define/static inline void/
2012-04-19 formatting new inline functions
2012-04-19 updated header
2012-04-19 woah, iotn44a.h is so much more useful than iotn44.h / iotnx4.h
2012-04-22 fixed fuse def
2012-04-23 commit of mostly working code
2012-04-23 cleaned void main() a bit
2012-04-24 cleaned up more stuff
2012-04-24 tore out the vast majority of TWI functionality, esp rx/tx buffers and sendData functions
2012-04-24 tore out more stuff. btw, this is tested/working.
2012-04-24 tore out some more stuff, tested/working
2012-04-24 inlined and removed inline functions
2012-04-24 killed garbage comments
2012-04-25 killed unnecessary includes
2012-04-25 oops, was falling through but not actually resetting...
2012-04-25 programming fuses every time you program the µC is a little tedious...
2012-04-25 freaking bitmath. been after this error for two days, turns out 0x04 != 1 << 0x04...
2012-04-26 port over routed row from dropbox
2012-04-26 added full 5x8 array
2012-04-27 invert logic to simplify xmega read/write interrupt issues with QC Enabled
2012-04-27 simplify initialization - no sense having separate config function when main.c only needs contain void main...
2012-04-27 comment all the things!
2012-04-27 added support for all-ctrl address, refactored pin control logic to clarify flow
2012-04-28 merged usiTwiSlave.c and main.c
2012-05-03 .8mm hole added
2012-05-03 board work.
2012-05-03 fixed power draw issues...
2012-05-15 added readme and licensing header
2012-05-15 oops, it's 2012.
2012-05-15 improved documentation
2012-05-15 clean up phrasing
2012-05-24 Connected vertically stacked boards
    Full 8-vertical layout now has power and SPI lines connected betwble een
    boards.
    Added the tessellatable layout go make arbitrarily high stacks.
2012-05-31 added masked pads for 3.3v, gnd, sda, and scl. changed vias from circular to octogonal to help spacing.
2012-06-01 added labels to breakout pins, moved pin1 indicators on freescale sensors to closer to pad
2012-06-03 initial commit of usb interface
2012-06-03 move to tPlace
2012-06-04 major rework of usb interface board - dropped Y by 5mm, cleaned routing, added better mounting.
2012-06-04 killed Dimension layer on the tessellateable board
2012-06-06 reworked silkscreen and snap on tesselate.brd
2012-06-06 tweak silkscreening - turns out eagle can write the 'align' attr, but not read it...
2012-06-06 added four row board w/ USB interface.
2012-06-06 silkscreen tweaks.
2012-06-06 square up mounting holes
2012-06-06 full 8 rows with standardized naming
2012-06-06 now with proper address pin configurations
2012-06-06 fixed few ERC glitches and ADDR routing
2012-06-06 removed unimaginative row
2012-06-06 removed roadkill
2012-06-06 fixed few drc issues w/ ground traces too close to addr pins
2012-06-06 goodbye airwires
2012-06-06 fix silkscreen outline of attiny
2012-06-06 extend silkscreen line
2012-06-06 a bit of branding.
2012-06-06 added cut line on bottom of PCB
2012-06-08 added www.biorobotics.harvard.edu/takktile
2012-06-08 added values for all the things
2012-06-08 small tweaks to naming - filled in C15 and fixed PROGX
2012-06-08 added BOM
2012-06-13 updated to match nonolith.lbr
2012-06-13 part not MMH, part MH
2012-06-13 removed old CSV, added new .xls and pdf
2012-06-19 fixed silkscreen branding, changed from mil to mm
2012-06-19 squared silkscreen branding
2012-06-19 modified with demarcated cut lines for separating the USB interface board from the array
2012-06-29 added usb-interface from fullArray
2012-06-29 rename to match camelCase conventions
2012-07-04 cleaned up comments
2012-07-19 s/attiny44/attiny24/
2012-07-21 'make program' now actually flashes fuses and firmware
2012-07-22 reduce IO calls by reading USIDR into temporary ADDR variable
2012-07-23 change cell indexing from 2d to 1d
2012-07-23 zero-index slaveAddress, set 0x0e as allcall, fix comment formatting, general forward progress
2012-07-24 polish comments
2012-07-24 right. fixed math error.
2012-07-24 off-by-one error. woot.
2012-07-26 0x0C and 0x0D now fall through address checking, added extra check to ensure that if going off of slaveAddress, matched addresses are have a lower nibble less than 0xA
2012-07-26 bitmath OR != logical OR != elif...
2012-07-26 something about premature optimization.
2012-11-10 s/0ms startup delay/64ms startup delay/
2012-11-10 comment, enable BOD @ 2.7v
2012-12-02 redo power section and host interface part of board
2012-12-02 start of repeatable / chainable rows w/ 7mm spacing and no vias under qfn tiny
2012-12-03 add 1206 decoupling capacitor to 5v0 supply
2012-12-20 update gitignore
2013-01-04 major rework of tesselate file - needs a tiny bit of tweaking for full tesselation
2013-01-04 add 7mm center-to-center ground pour on bottom
2013-01-04 should tesselate now. I am excite.
2013-01-04 one index sensors
2013-01-07 straighten between-row lines to facilitate maximally tight spacing
2013-01-07 add via for continuous ground pour
2013-01-07 6mm row-row spacing, numbers at top of sensor, should be good to go for tesselation
2013-01-07 align traces for tessellation. hopefully the last modification needed to this board...
2013-01-08 explicit ground connections, remove bothersome ground via
2013-01-09 rename some signals and stuff
2013-01-09 added up to date usb interface board
2013-01-09 fix numbering scheme for tesselation
2013-01-09 need to tweak address pins, but should be manufacturable
2013-01-09 no airwires save address pins
2013-01-09 fixed addressing logic pin assignment, zero airwires, zero todos
2013-01-09 cosmetic rearrangements, drop programming header on xmega, center board
2013-01-09 center, center, and recenter...
2013-01-09 shorten board by 2mm, move mounting holes in
2013-01-10 drop 4-40 header holes for 2.4mm holes, clean a few dimensions
2013-01-10 once again, tweak the outline.
2013-01-10 added branding, version number, and reorganized 4 lines out of USB array to match layout on board
2013-01-10 s/proportional font/vector font/, move a few traces to 45deg
2013-01-18 initial commit of naive multi-sample addressing code; use shifter & accumulator to average eight calls of getAddress();
2013-01-25 initial commit of attiny-friendly statistical mode calculator. hello qsort on 8mhz cpu...
2013-01-29 small tweaks to pass ITead DRC
2013-02-10 1) Addresing problem was fixed 2) Dedicated code for TakkTile addressing was included
2013-03-04 s/0603 resistor/solder jumper/, clean power traces, add 0.5mm vias for PDI-DATA and PDI-CLK
2013-11-19 restructuring folders
2013-12-10 reorganized repo by board
2013-12-10 added 6-sensor addressing
2013-12-10 added Makefile
2013-12-10 removed firmware folder (moved inside individual projects)
2013-12-10 renamed to distinguish from bootloader
2014-02-25 added takkfast
2015-12-16 Added new instructions for compiling on 14.04
2015-12-16 Removing TakkFast
    It's already in TakkTile-usb which is the repo mentioned in our
    documentation. Also, the version here is old and the submodule import
    does not work.
