# Repository TakkTile/takktile-boards

## EAGLE design takkarray/tessellate.brd

Parts:
01, 02, 03, 04, 05: MPL115A; LGA-8
C01, C02, C03, C04, C05, C6: CAP_CERAMIC0402; 0402
UC01: ATTINY24QFN; QFN20

Connections:
3.3V: 01.1 (VDD), 01.4 (SHDN), 02.1 (VDD), 02.4 (SHDN), 03.1 (VDD), 03.4 (SHDN), 04.1 (VDD), 04.4 (SHDN), 05.1 (VDD), 05.4 (SHDN), C6.1, UC01.9 (VCC)
ADDR00: UC01.11 (PB0)
CAP01: 01.2 (CAP), C01.1
CAP02: 02.2 (CAP), C02.1
CAP03: 03.2 (CAP), C03.1
CAP04: 04.2 (CAP), C04.1
CAP05: 05.2 (CAP), C05.1
GND: 01.3 (GND), 02.3 (GND), 03.3 (GND), 04.3 (GND), 05.3 (GND), C01.2, C02.2, C03.2, C04.2, C05.2, C6.2, UC01.0 (GND), UC01.8 (GND), UC01.12 (PB1), UC01.14 (PB2), UC01.15 (PA7/ADC7)
RESET01: UC01.13 (PB3/RESET)
RST01: 01.5 (RST), UC01.5 (PA0/ADC0)
RST02: 02.5 (RST), UC01.4 (PA1/ADC1)
RST03: 03.5 (RST), UC01.3 (PA2/ADC2)
RST04: 04.5 (RST), UC01.2 (PA3/ADC3)
RST05: 05.5 (RST), UC01.20 (PA5/MISO)
SCL: 01.8 (SCL), 02.8 (SCL), 03.8 (SCL), 04.8 (SCL), 05.8 (SCL), UC01.1 (PA4/SCL)
SDA: 01.7 (SDA), 02.7 (SDA), 03.7 (SDA), 04.7 (SDA), 05.7 (SDA), UC01.16 (PA6/MOSI)

Board: 2 copper layers, 12 parts (7 on the bottom side), 14 nets.

## EAGLE design eagle/fullArray.brd

Parts:
3.3V: VREGAP1117; SOT223
C10: 1uF; 0603
C11: .1uF; 0603
C12: .01uF; 0603
C52: 470uF; EIA7343-31/D-R
C53: 10uF; 1206
CN1: USBMICROB; USB-MICROB
DAISY: HEADER-1X62MM; 1X06_ROUND_2MM
JP1, JP2: HEADER-1X12MM; 1X01_2MM
LED1: LED0603; CHIPLED_0603
R1: 120o; 0603
R2, R3: 4.7K; 0603
R4: 4.7k; 0603
SCL: HEADER-1X12MM; 1X01_2MM
SDA: HEADER-1X12MM; 1X01_2MM
XM1: ATXMEGAXXA4U-MH; QFN-44

Connections:
3.3V: 3.3V.2 (VO), 3.3V.4 (VO), C10.2, C11.2, C12.2, C52.+, JP2.1, R2.2, R3.2, R4.2, XM1.9 (VCC), XM1.19 (VCC), XM1.31 (VCC), XM1.39 (AVCC); also elsewhere on the board
5V: 3.3V.3 (VIN), C53.2, CN1.P1 (VBUS), DAISY.6
BOOTLOAD: XM1.36 (PR0/XTAL2)
GND: 3.3V.1 (GND), C10.1, C11.1, C12.1, C52.-, C53.1, CN1.P5 (GND), DAISY.1, JP1.1, LED1.C, XM1.8 (GND), XM1.18 (GND), XM1.30 (GND), XM1.38 (GND); also elsewhere on the board
PDI-CLK: XM1.35 (RESET/PDI-CLK)
PDI-DATA: XM1.34 (PDI-DATA)
PE0: DAISY.5, R4.1, XM1.28 (OC0A/SDA/PE0)
PE1: DAISY.4, XM1.29 (XCK0/OC0B/SCL/PE1)
PE2: DAISY.3, XM1.32 (RXD0/OC0C/PE2)
PE3: DAISY.2, XM1.33 (TXD0/OC0D/PE3)
PR1: R1.1, XM1.37 (PR1/XTAL1)
PR1-P: LED1.A, R1.2
SCL: R2.1, SCL.1, XM1.11 (PC1/OC0B/XCK0/SCL); also elsewhere on the board
SDA: R3.1, SDA.1, XM1.10 (PC0/OC0A/SDA); also elsewhere on the board
USB+: CN1.P3 (D+), XM1.27 (TXD1/USB+/PD7)
USB-: CN1.P2 (D-), XM1.26 (RXD1/MISO/USB-/PD6)

Parts:
01, 02, 03, 04, 05: MPL115A; LGA-8
C01, C02, C03, C04, C05, C6: CAP_CERAMIC0402; 0402
UC01: ATTINY24QFN; QFN20

Connections:
3.3V: 01.1 (VDD), 01.4 (SHDN), 02.1 (VDD), 02.4 (SHDN), 03.1 (VDD), 03.4 (SHDN), 04.1 (VDD), 04.4 (SHDN), 05.1 (VDD), 05.4 (SHDN), C6.1, UC01.9 (VCC); also elsewhere on the board
ADDR1A: UC01.11 (PB0)
CAP01: 01.2 (CAP), C01.1
CAP02: 02.2 (CAP), C02.1
CAP03: 03.2 (CAP), C03.1
CAP04: 04.2 (CAP), C04.1
CAP05: 05.2 (CAP), C05.1
GND: 01.3 (GND), 02.3 (GND), 03.3 (GND), 04.3 (GND), 05.3 (GND), C01.2, C02.2, C03.2, C04.2, C05.2, C6.2, UC01.0 (GND), UC01.8 (GND), UC01.12 (PB1), UC01.14 (PB2), UC01.15 (PA7/ADC7); also elsewhere on the board
RESET01: UC01.13 (PB3/RESET)
RST01: 01.5 (RST), UC01.5 (PA0/ADC0)
RST02: 02.5 (RST), UC01.4 (PA1/ADC1)
RST03: 03.5 (RST), UC01.3 (PA2/ADC2)
RST04: 04.5 (RST), UC01.2 (PA3/ADC3)
RST05: 05.5 (RST), UC01.20 (PA5/MISO)
SCL: 01.8 (SCL), 02.8 (SCL), 03.8 (SCL), 04.8 (SCL), 05.8 (SCL), UC01.1 (PA4/SCL); also elsewhere on the board
SDA: 01.7 (SDA), 02.7 (SDA), 03.7 (SDA), 04.7 (SDA), 05.7 (SDA), UC01.16 (PA6/MOSI); also elsewhere on the board

Parts:
06, 07, 08, 09, 10: MPL115A; LGA-8
C07, C08, C09, C13, C14, C15: CAP_CERAMIC0402; 0402
UC02: ATTINY24QFN; QFN20

Connections:
3.3V: 06.1 (VDD), 06.4 (SHDN), 07.1 (VDD), 07.4 (SHDN), 08.1 (VDD), 08.4 (SHDN), 09.1 (VDD), 09.4 (SHDN), 10.1 (VDD), 10.4 (SHDN), C15.1, UC02.9 (VCC); also elsewhere on the board
ADDR2A: UC02.12 (PB1)
CAP06: 08.2 (CAP), C09.1
CAP07: 09.2 (CAP), C13.1
CAP08: 10.2 (CAP), C14.1
CAP09: 06.2 (CAP), C07.1
CAP10: 07.2 (CAP), C08.1
GND: 06.3 (GND), 07.3 (GND), 08.3 (GND), 09.3 (GND), 10.3 (GND), C07.2, C08.2, C09.2, C13.2, C14.2, C15.2, UC02.0 (GND), UC02.8 (GND), UC02.11 (PB0), UC02.14 (PB2), UC02.15 (PA7/ADC7); also elsewhere on the board
RESET02: UC02.13 (PB3/RESET)
RST06: 06.5 (RST), UC02.5 (PA0/ADC0)
RST07: 07.5 (RST), UC02.4 (PA1/ADC1)
RST08: 08.5 (RST), UC02.3 (PA2/ADC2)
RST09: 09.5 (RST), UC02.2 (PA3/ADC3)
RST10: 10.5 (RST), UC02.20 (PA5/MISO)
SCL: 06.8 (SCL), 07.8 (SCL), 08.8 (SCL), 09.8 (SCL), 10.8 (SCL), UC02.1 (PA4/SCL); also elsewhere on the board
SDA: 06.7 (SDA), 07.7 (SDA), 08.7 (SDA), 09.7 (SDA), 10.7 (SDA), UC02.16 (PA6/MOSI); also elsewhere on the board

Parts:
11, 12, 13, 14, 15: MPL115A; LGA-8
C16, C17, C18, C19, C20, C21: CAP_CERAMIC0402; 0402
UC03: ATTINY24QFN; QFN20

Connections:
3.3V: 11.1 (VDD), 11.4 (SHDN), 12.1 (VDD), 12.4 (SHDN), 13.1 (VDD), 13.4 (SHDN), 14.1 (VDD), 14.4 (SHDN), 15.1 (VDD), 15.4 (SHDN), C21.1, UC03.9 (VCC); also elsewhere on the board
ADDR3A: UC03.11 (PB0)
ADDR3B: UC03.12 (PB1)
CAP11: 13.2 (CAP), C18.1
CAP12: 14.2 (CAP), C19.1
CAP13: 15.2 (CAP), C20.1
CAP14: 11.2 (CAP), C16.1
CAP15: 12.2 (CAP), C17.1
GND: 11.3 (GND), 12.3 (GND), 13.3 (GND), 14.3 (GND), 15.3 (GND), C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, UC03.0 (GND), UC03.8 (GND), UC03.14 (PB2), UC03.15 (PA7/ADC7); also elsewhere on the board
RESET03: UC03.13 (PB3/RESET)
RST11: 11.5 (RST), UC03.5 (PA0/ADC0)
RST12: 12.5 (RST), UC03.4 (PA1/ADC1)
RST13: 13.5 (RST), UC03.3 (PA2/ADC2)
RST14: 14.5 (RST), UC03.2 (PA3/ADC3)
RST15: 15.5 (RST), UC03.20 (PA5/MISO)
SCL: 11.8 (SCL), 12.8 (SCL), 13.8 (SCL), 14.8 (SCL), 15.8 (SCL), UC03.1 (PA4/SCL); also elsewhere on the board
SDA: 11.7 (SDA), 12.7 (SDA), 13.7 (SDA), 14.7 (SDA), 15.7 (SDA), UC03.16 (PA6/MOSI); also elsewhere on the board

Parts:
16, 17, 18, 19, 20: MPL115A; LGA-8
C22, C23, C24, C25, C26, C27: CAP_CERAMIC0402; 0402
UC04: ATTINY24QFN; QFN20

Connections:
3.3V: 16.1 (VDD), 16.4 (SHDN), 17.1 (VDD), 17.4 (SHDN), 18.1 (VDD), 18.4 (SHDN), 19.1 (VDD), 19.4 (SHDN), 20.1 (VDD), 20.4 (SHDN), C27.1, UC04.9 (VCC); also elsewhere on the board
ADDR4A: UC04.14 (PB2)
CAP16: 18.2 (CAP), C24.1
CAP17: 19.2 (CAP), C25.1
CAP18: 20.2 (CAP), C26.1
CAP19: 16.2 (CAP), C22.1
CAP20: 17.2 (CAP), C23.1
GND: 16.3 (GND), 17.3 (GND), 18.3 (GND), 19.3 (GND), 20.3 (GND), C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, UC04.0 (GND), UC04.8 (GND), UC04.11 (PB0), UC04.12 (PB1), UC04.15 (PA7/ADC7); also elsewhere on the board
RESET04: UC04.13 (PB3/RESET)
RST16: 16.5 (RST), UC04.5 (PA0/ADC0)
RST17: 17.5 (RST), UC04.4 (PA1/ADC1)
RST018: 18.5 (RST), UC04.3 (PA2/ADC2)
RST19: 19.5 (RST), UC04.2 (PA3/ADC3)
RST20: 20.5 (RST), UC04.20 (PA5/MISO)
SCL: 16.8 (SCL), 17.8 (SCL), 18.8 (SCL), 19.8 (SCL), 20.8 (SCL), UC04.1 (PA4/SCL); also elsewhere on the board
SDA: 16.7 (SDA), 17.7 (SDA), 18.7 (SDA), 19.7 (SDA), 20.7 (SDA), UC04.16 (PA6/MOSI); also elsewhere on the board

Parts:
21, 22, 23, 24, 25: MPL115A; LGA-8
C28, C29, C30, C31, C32, C33: CAP_CERAMIC0402; 0402
UC05: ATTINY24QFN; QFN20

Connections:
3.3V: 21.1 (VDD), 21.4 (SHDN), 22.1 (VDD), 22.4 (SHDN), 23.1 (VDD), 23.4 (SHDN), 24.1 (VDD), 24.4 (SHDN), 25.1 (VDD), 25.4 (SHDN), C33.1, UC05.9 (VCC); also elsewhere on the board
ADDR5A: UC05.11 (PB0)
ADDR5B: UC05.14 (PB2)
CAP21: 23.2 (CAP), C30.1
CAP22: 24.2 (CAP), C31.1
CAP23: 25.2 (CAP), C32.1
CAP24: 21.2 (CAP), C28.1
CAP25: 22.2 (CAP), C29.1
GND: 21.3 (GND), 22.3 (GND), 23.3 (GND), 24.3 (GND), 25.3 (GND), C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, UC05.0 (GND), UC05.8 (GND), UC05.12 (PB1), UC05.15 (PA7/ADC7); also elsewhere on the board
RESET05: UC05.13 (PB3/RESET)
RST21: 21.5 (RST), UC05.5 (PA0/ADC0)
RST22: 22.5 (RST), UC05.4 (PA1/ADC1)
RST23: 23.5 (RST), UC05.3 (PA2/ADC2)
RST24: 24.5 (RST), UC05.2 (PA3/ADC3)
RST25: 25.5 (RST), UC05.20 (PA5/MISO)
SCL: 21.8 (SCL), 22.8 (SCL), 23.8 (SCL), 24.8 (SCL), 25.8 (SCL), UC05.1 (PA4/SCL); also elsewhere on the board
SDA: 21.7 (SDA), 22.7 (SDA), 23.7 (SDA), 24.7 (SDA), 25.7 (SDA), UC05.16 (PA6/MOSI); also elsewhere on the board

Parts:
26, 27, 28, 29, 30: MPL115A; LGA-8
C34, C35, C36, C37, C38, C39: CAP_CERAMIC0402; 0402
UC06: ATTINY24QFN; QFN20

Connections:
3.3V: 26.1 (VDD), 26.4 (SHDN), 27.1 (VDD), 27.4 (SHDN), 28.1 (VDD), 28.4 (SHDN), 29.1 (VDD), 29.4 (SHDN), 30.1 (VDD), 30.4 (SHDN), C39.1, UC06.9 (VCC); also elsewhere on the board
ADDR6A: UC06.12 (PB1)
ADDR6B: UC06.14 (PB2)
CAP26: 28.2 (CAP), C36.1
CAP27: 29.2 (CAP), C37.1
CAP28: 30.2 (CAP), C38.1
CAP29: 26.2 (CAP), C34.1
CAP30: 27.2 (CAP), C35.1
GND: 26.3 (GND), 27.3 (GND), 28.3 (GND), 29.3 (GND), 30.3 (GND), C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, UC06.0 (GND), UC06.8 (GND), UC06.11 (PB0), UC06.15 (PA7/ADC7); also elsewhere on the board
RESET06: UC06.13 (PB3/RESET)
RST26: 26.5 (RST), UC06.5 (PA0/ADC0)
RST27: 27.5 (RST), UC06.4 (PA1/ADC1)
RST28: 28.5 (RST), UC06.3 (PA2/ADC2)
RST29: 29.5 (RST), UC06.2 (PA3/ADC3)
RST30: 30.5 (RST), UC06.20 (PA5/MISO)
SCL: 26.8 (SCL), 27.8 (SCL), 28.8 (SCL), 29.8 (SCL), 30.8 (SCL), UC06.1 (PA4/SCL); also elsewhere on the board
SDA: 26.7 (SDA), 27.7 (SDA), 28.7 (SDA), 29.7 (SDA), 30.7 (SDA), UC06.16 (PA6/MOSI); also elsewhere on the board

Parts:
31, 32, 33, 34, 35: MPL115A; LGA-8
C40, C41, C42, C43, C44, C45: CAP_CERAMIC0402; 0402
UC07: ATTINY24QFN; QFN20

Connections:
3.3V: 31.1 (VDD), 31.4 (SHDN), 32.1 (VDD), 32.4 (SHDN), 33.1 (VDD), 33.4 (SHDN), 34.1 (VDD), 34.4 (SHDN), 35.1 (VDD), 35.4 (SHDN), C45.1, UC07.9 (VCC); also elsewhere on the board
ADDR7A: UC07.11 (PB0)
ADDR7B: UC07.12 (PB1)
ADDR7C: UC07.14 (PB2)
CAP31: 33.2 (CAP), C42.1
CAP32: 34.2 (CAP), C43.1
CAP33: 35.2 (CAP), C44.1
CAP34: 31.2 (CAP), C40.1
CAP35: 32.2 (CAP), C41.1
GND: 31.3 (GND), 32.3 (GND), 33.3 (GND), 34.3 (GND), 35.3 (GND), C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, UC07.0 (GND), UC07.8 (GND), UC07.15 (PA7/ADC7); also elsewhere on the board
RESET07: UC07.13 (PB3/RESET)
RST31: 31.5 (RST), UC07.5 (PA0/ADC0)
RST32: 32.5 (RST), UC07.4 (PA1/ADC1)
RST33: 33.5 (RST), UC07.3 (PA2/ADC2)
RST34: 34.5 (RST), UC07.2 (PA3/ADC3)
RST35: 35.5 (RST), UC07.20 (PA5/MISO)
SCL: 31.8 (SCL), 32.8 (SCL), 33.8 (SCL), 34.8 (SCL), 35.8 (SCL), UC07.1 (PA4/SCL); also elsewhere on the board
SDA: 31.7 (SDA), 32.7 (SDA), 33.7 (SDA), 34.7 (SDA), 35.7 (SDA), UC07.16 (PA6/MOSI); also elsewhere on the board

Schematic: fullArray.sch, sheet 9

Parts:
36, 37, 38, 39, 40: MPL115A; LGA-8
C46, C47, C48, C49, C50, C51: CAP_CERAMIC0402; 0402
UC08: ATTINY24QFN; QFN20

Connections:
3.3V: 36.1 (VDD), 36.4 (SHDN), 37.1 (VDD), 37.4 (SHDN), 38.1 (VDD), 38.4 (SHDN), 39.1 (VDD), 39.4 (SHDN), 40.1 (VDD), 40.4 (SHDN), C51.1, UC08.9 (VCC); also elsewhere on the board
ADDR8A: UC08.15 (PA7/ADC7)
CAP36: 38.2 (CAP), C48.1
CAP37: 39.2 (CAP), C49.1
CAP38: 40.2 (CAP), C50.1
CAP39: 36.2 (CAP), C46.1
CAP40: 37.2 (CAP), C47.1
GND: 36.3 (GND), 37.3 (GND), 38.3 (GND), 39.3 (GND), 40.3 (GND), C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, UC08.0 (GND), UC08.8 (GND), UC08.11 (PB0), UC08.12 (PB1), UC08.14 (PB2); also elsewhere on the board
RESET08: UC08.13 (PB3/RESET)
RST36: 36.5 (RST), UC08.5 (PA0/ADC0)
RST37: 37.5 (RST), UC08.4 (PA1/ADC1)
RST38: 38.5 (RST), UC08.3 (PA2/ADC2)
RST39: 39.5 (RST), UC08.2 (PA3/ADC3)
RST40: 40.5 (RST), UC08.20 (PA5/MISO)
SCL: 36.8 (SCL), 37.8 (SCL), 38.8 (SCL), 39.8 (SCL), 40.8 (SCL), UC08.1 (PA4/SCL); also elsewhere on the board
SDA: 36.7 (SDA), 37.7 (SDA), 38.7 (SDA), 39.7 (SDA), 40.7 (SDA), UC08.16 (PA6/MOSI); also elsewhere on the board

Board: 2 copper layers, 29.0 x 70.0 mm, 115 parts (57 on the bottom side), 93 nets.

Other parts of the board:
U$5: LOGO_NONOLITH

File eagle/fullArray.BOM.csv:

Part,Value,Package

"(1,1)",MPL115A2,LGA-8
"(1,2)",MPL115A2,LGA-8
"(1,3)",MPL115A2,LGA-8
"(1,4)",MPL115A2,LGA-8
"(1,5)",MPL115A2,LGA-8
"(2,1)",MPL115A2,LGA-8
"(2,2)",MPL115A2,LGA-8
"(2,3)",MPL115A2,LGA-8
"(2,4)",MPL115A2,LGA-8
"(2,5)",MPL115A2,LGA-8
"(3,1)",MPL115A2,LGA-8
"(3,2)",MPL115A2,LGA-8
"(3,3)",MPL115A2,LGA-8
"(3,4)",MPL115A2,LGA-8
"(3,5)",MPL115A2,LGA-8
"(4,1)",MPL115A2,LGA-8
"(4,2)",MPL115A2,LGA-8
"(4,3)",MPL115A2,LGA-8
"(4,4)",MPL115A2,LGA-8
"(4,5)",MPL115A2,LGA-8
"(5,1)",MPL115A2,LGA-8
"(5,2)",MPL115A2,LGA-8
"(5,3)",MPL115A2,LGA-8
"(5,4)",MPL115A2,LGA-8
"(5,5)",MPL115A2,LGA-8
"(6,1)",MPL115A2,LGA-8
"(6,2)",MPL115A2,LGA-8
"(6,3)",MPL115A2,LGA-8
"(6,4)",MPL115A2,LGA-8
"(6,5)",MPL115A2,LGA-8
"(7,1)",MPL115A2,LGA-8
"(7,2)",MPL115A2,LGA-8
"(7,3)",MPL115A2,LGA-8
"(7,4)",MPL115A2,LGA-8
"(7,5)",MPL115A2,LGA-8
"(8,1)",MPL115A2,LGA-8
"(8,2)",MPL115A2,LGA-8
"(8,3)",MPL115A2,LGA-8
"(8,4)",MPL115A2,LGA-8
"(8,5)",MPL115A2,LGA-8
3.3V,VREG,SOT23-3
AT1,ATTINY24QFN,QFN-20
AT2,ATTINY24QFN,QFN-20
AT3,ATTINY24QFN,QFN-20
AT4,ATTINY24QFN,QFN-20
AT5,ATTINY24QFN,QFN-20
AT6,ATTINY24QFN,QFN-20
AT7,ATTINY24QFN,QFN-20
AT8,ATTINY24QFN,QFN-20
C0,1uF,0603
C1,1uF,0603
C2,1uF,0603
C3,1uF,0603
C4,1uF,0603
C5,1uF,0603
C6,1uF,0603
C7,1uF,0603
C8,1uF,0603
C9,1uF,0603
C10,1uF,0603
C11,.1uF,0603
C12,.01uF,0603
C13,1uF,0603
C14,1uF,0603
C15,1uF,0603
C16,1uF,0603
C17,1uF,0603
C18,1uF,0603
C19,1uF,0603
C20,1uF,0603
C21,1uF,0603
C22,1uF,0603
C23,1uF,0603
C24,1uF,0603
C25,1uF,0603
C26,1uF,0603
C27,1uF,0603
C28,1uF,0603
C29,1uF,0603
C30,1uF,0603
C31,1uF,0603
C32,1uF,0603
C33,1uF,0603
C34,1uF,0603
C35,1uF,0603
C36,1uF,0603
C37,1uF,0603
C38,1uF,0603
C39,1uF,0603
C40,1uF,0603
C41,1uF,0603
C42,1uF,0603
CN1,609-4613-1-ND,USB-MICROB
LED1,RED,CHIPLED_0603
R1,120o,0603
R2,4.7K,0603
R3,4.7K,0603
R4,4.7k,0603
XM1,XMEGA32A4U-MH,QFN-44

## EAGLE design eagle/row.brd

Parts:
C0, C1, C2, C3, C4: CAP_CERAMIC0603; 0603
PROG: HEADER-2X3; 2X03
S00, S10, S20, S30, S40: MPL115A; LGA-8
UC0: ATTINY24QFN; QFN20

Connections:
3.3V: PROG.2, S00.1 (VDD), S00.4 (SHDN), S10.1 (VDD), S10.4 (SHDN), S20.1 (VDD), S20.4 (SHDN), S30.1 (VDD), S30.4 (SHDN), S40.1 (VDD), S40.4 (SHDN), UC0.9 (VCC)
ADDR00: UC0.11 (PB0)
CAP00: C0.1, S00.2 (CAP)
CAP10: C1.1, S10.2 (CAP)
CAP20: C2.1, S20.2 (CAP)
CAP30: C3.1, S30.2 (CAP)
CAP40: C4.1, S40.2 (CAP)
GND: C0.2, C1.2, C2.2, C3.2, C4.2, PROG.6, S00.3 (GND), S10.3 (GND), S20.3 (GND), S30.3 (GND), S40.3 (GND), UC0.0 (GND), UC0.8 (GND), UC0.12 (PB1), UC0.14 (PB2), UC0.15 (PA7/ADC7)
RESET0: PROG.5, UC0.13 (PB3/RESET)
RST00: S00.5 (RST), UC0.5 (PA0/ADC0)
RST10: S10.5 (RST), UC0.4 (PA1/ADC1)
RST20: S20.5 (RST), UC0.3 (PA2/ADC2)
RST30: S30.5 (RST), UC0.2 (PA3/ADC3)
RST40: PROG.1, S40.5 (RST), UC0.20 (PA5/MISO)
SCL: PROG.3, S00.8 (SCL), S10.8 (SCL), S20.8 (SCL), S30.8 (SCL), S40.8 (SCL), UC0.1 (PA4/SCL)
SDA: PROG.4, S00.7 (SDA), S10.7 (SDA), S20.7 (SDA), S30.7 (SDA), S40.7 (SDA), UC0.16 (PA6/MOSI)

Board: 2 copper layers, 39.8 x 6.0 mm, 12 parts (6 on the bottom side), 15 nets.

## EAGLE design eagle/roadkill.brd

Parts:
3.3V: VREG; SOT23-3
C10: 1uF; 0603
C11: .1uF; 0603
C12: .01uF; 0603
CN1: USBMINIB; USB-MINIB
IC1: ATXMEGAXXA4U; TQFP-44
LED1: LED0603; CHIPLED_0603
PROG-XMEGA: HEADER-2X3; 2X03
R1, R2, R3: RESISTOR0603; 0603

Connections:
3.3V: 3.3V.2 (VO), C10.2, C11.2, C12.2, IC1.9 (VCC), IC1.19 (VCC), IC1.31 (VCC), IC1.39 (AVCC), PROG-XMEGA.2, R2.2, R3.2; also elsewhere on the board
5V: 3.3V.3 (VIN), CN1.VBUS
BOOTLOAD: IC1.36 (PR0/XTAL2), PROG-XMEGA.4
GND: 3.3V.1 (GND), C10.1, C11.1, C12.1, CN1.GND, IC1.8 (GND), IC1.18 (GND), IC1.30 (GND), IC1.38 (GND), LED1.C, PROG-XMEGA.6; also elsewhere on the board
PDI-CLK: IC1.35 (RESET/PDI-CLK), PROG-XMEGA.5
PDI-DATA: IC1.34 (PDI-DATA), PROG-XMEGA.1
PR1: IC1.37 (PR1/XTAL1), R1.1
PR1-P: LED1.A, R1.2
SCL: IC1.11 (PC1/OC0B/XCK0/SCL), R2.1; also elsewhere on the board
SDA: IC1.10 (PC0/OC0A/SDA), R3.1; also elsewhere on the board
USB+: CN1.D+, IC1.27 (TXD1/USB+/PD7)
USB-: CN1.D-, IC1.26 (RXD1/MISO/USB-/PD6)

Parts:
C0, C1, C2, C3, C4: CAP_CERAMIC0603; 0603
OUT: HEADER-1X4; 1X04_OVAL
PROG0: HEADER-2X3; 2X03
S00, S10, S20, S30, S40: MPL115A; LGA-8
UC0: ATTINY24QFN; QFN20

Connections:
3.3V: OUT.4, PROG0.2, S00.1 (VDD), S00.4 (SHDN), S10.1 (VDD), S10.4 (SHDN), S20.1 (VDD), S20.4 (SHDN), S30.1 (VDD), S30.4 (SHDN), S40.1 (VDD), S40.4 (SHDN), UC0.9 (VCC); also elsewhere on the board
ADDR00: UC0.11 (PB0)
CAP00: C0.1, S00.2 (CAP)
CAP10: C1.1, S10.2 (CAP)
CAP20: C2.1, S20.2 (CAP)
CAP30: C3.1, S30.2 (CAP)
CAP40: C4.1, S40.2 (CAP)
GND: C0.2, C1.2, C2.2, C3.2, C4.2, OUT.1, PROG0.6, S00.3 (GND), S10.3 (GND), S20.3 (GND), S30.3 (GND), S40.3 (GND), UC0.0 (GND), UC0.8 (GND), UC0.12 (PB1), UC0.14 (PB2), UC0.15 (PA7/ADC7); also elsewhere on the board
RESET0: PROG0.5, UC0.13 (PB3/RESET)
RST00: S00.5 (RST), UC0.5 (PA0/ADC0)
RST10: S10.5 (RST), UC0.4 (PA1/ADC1)
RST20: S20.5 (RST), UC0.3 (PA2/ADC2)
RST30: S30.5 (RST), UC0.2 (PA3/ADC3)
RST40: PROG0.1, S40.5 (RST), UC0.20 (PA5/MISO)
SCL: OUT.2, PROG0.3, S00.8 (SCL), S10.8 (SCL), S20.8 (SCL), S30.8 (SCL), S40.8 (SCL), UC0.1 (PA4/SCL); also elsewhere on the board
SDA: OUT.3, PROG0.4, S00.7 (SDA), S10.7 (SDA), S20.7 (SDA), S30.7 (SDA), S40.7 (SDA), UC0.16 (PA6/MOSI); also elsewhere on the board

Parts:
C5, C6, C7, C8, C9: CAP_CERAMIC0603; 0603
PROG1: HEADER-2X3; 2X03
S01, S11, S21, S31, S41: MPL115A; LGA-8
UC1: ATTINY24QFN; QFN20

Connections:
3.3V: PROG1.2, S01.1 (VDD), S01.4 (SHDN), S11.1 (VDD), S11.4 (SHDN), S21.1 (VDD), S21.4 (SHDN), S31.1 (VDD), S31.4 (SHDN), S41.1 (VDD), S41.4 (SHDN), UC1.9 (VCC); also elsewhere on the board
ADDR11: UC1.12 (PB1)
CAP01: C5.1, S01.2 (CAP)
CAP11: C6.1, S11.2 (CAP)
CAP21: C7.1, S21.2 (CAP)
CAP31: C8.1, S31.2 (CAP)
CAP41: C9.1, S41.2 (CAP)
GND: C5.2, C6.2, C7.2, C8.2, C9.2, PROG1.6, S01.3 (GND), S11.3 (GND), S21.3 (GND), S31.3 (GND), S41.3 (GND), UC1.0 (GND), UC1.8 (GND), UC1.11 (PB0), UC1.14 (PB2), UC1.15 (PA7/ADC7); also elsewhere on the board
RESET1: PROG1.5, UC1.13 (PB3/RESET)
RST01: S01.5 (RST), UC1.5 (PA0/ADC0)
RST11: S11.5 (RST), UC1.4 (PA1/ADC1)
RST21: S21.5 (RST), UC1.3 (PA2/ADC2)
RST31: S31.5 (RST), UC1.2 (PA3/ADC3)
RST41: PROG1.1, S41.5 (RST), UC1.20 (PA5/MISO)
SCL: PROG1.3, S01.8 (SCL), S11.8 (SCL), S21.8 (SCL), S31.8 (SCL), S41.8 (SCL), UC1.1 (PA4/SCL); also elsewhere on the board
SDA: PROG1.4, S01.7 (SDA), S11.7 (SDA), S21.7 (SDA), S31.7 (SDA), S41.7 (SDA), UC1.16 (PA6/MOSI); also elsewhere on the board
